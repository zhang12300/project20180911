# IAR project Backup (2) of demoLQ_KV58F24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 Freescale MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pm008
  ICCARM.CCIncludePath2: \Users\Administrator.000\Desktop\KV58的\LQuser\devices\; \Users\Administrator.000\Desktop\KV58的\LQuser\devices\include\; \Users\Administrator.000\Desktop\KV58的\LQuser\devices\startup\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\inc\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\src\abase\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\src\flash\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\src\mmcau\asm-cm0p\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\src\mmcau\asm-cm4-cm7\; \Users\Administrator.000\Desktop\KV58的\LQuser\drivers\src\sdcard\; \Users\Administrator.000\Desktop\KV58的\LQuser\osa\; \Users\Administrator.000\Desktop\KV58的\LQuser\system\; \Users\Administrator.000\Desktop\KV58的\LQuser\user\; \Users\Administrator.000\Desktop\KV58的\LQuser\utilities\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: demoLQ_KV58F24.hex
  ILINK.IlinkOutputFile: gpio_example.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: LQuser\devices\linker\MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24
  ICCARM.CCIncludePath2: LQuser/devices/include; LQuser/devices/startup; LQuser/devices; LQuser/drivers/inc; LQuser/drivers/src; LQuser/osa; LQuser/system; LQuser/user; LQuser/utilities; ../../..; \WorkingArea\竞赛\底层函数\KV58的\LQuser\devices\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\devices\include\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\devices\startup\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\inc\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\src\abase\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\src\flash\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\src\mmcau\asm-cm0p\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\src\mmcau\asm-cm4-cm7\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\drivers\src\sdcard\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\osa\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\system\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\user\; \WorkingArea\竞赛\底层函数\KV58的\LQuser\utilities\
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: gpio_example.srec
  ILINK.IlinkIcfFile: LQuser/devices/linker/MKV58F1M0xxx24_flash.icf
  group driver/HSADC
    LQuser/drivers/src/hsadc/: fsl_hsadc_common.c fsl_hsadc_driver.c fsl_hsadc_hal.c
    LQuser/drivers/inc/: fsl_hsadc_driver.h fsl_hsadc_hal.h
  group driver/sysbase
    LQuser/drivers/src/abase/: fsl_dmamux_hal.c fsl_llwu_hal.c fsl_mcg_hal.c fsl_mcg_hal_modes.c fsl_mscm_hal.c fsl_osc_hal.c fsl_port_hal.c fsl_rcm_hal.c fsl_sim_hal_MKV58F24.c fsl_sim_hal_MKV58F24.h fsl_smc_hal.c
  group startup
    LQuser/devices/startup/: startup.c startup.h startup_MKV58F24.s system_MKV58F24.c system_MKV58F24.h
  group system
    LQuser/system/: fsl_clock_manager.c fsl_clock_manager.h fsl_clock_manager_common.c fsl_clock_MKV58F24.c fsl_clock_MKV58F24.h fsl_hwtimer.c fsl_hwtimer.h fsl_hwtimer_pit.c fsl_hwtimer_pit.h fsl_hwtimer_systick.c fsl_hwtimer_systick.h fsl_hwtimer_systick_irq.c fsl_interrupt_manager.c fsl_interrupt_manager.h fsl_interrupt_manager_common.c fsl_interrupt_manager_irq.c fsl_power_manager.c fsl_power_manager.h fsl_power_manager_common.h pin_mux.c pin_mux.h
    LQuser/devices/: fsl_device_registers.h
  group user
    LQuser/user/: APPmain.c common.h control.c control.h debug.c debug.h function.c function.h Fuzzy.c Fuzzy.h include.h LPTMR.c LPTMR.h LQ12864.h LQ12864SPI.c LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_PLL.c LQ_PLL.h LQ_SGP18T.c LQ_SGP18T.h LQADC.c LQADC.h LQDMA.c LQDMA.h LQFTM.c LQFTM.h LQGPIO.c LQGPIO.h LQGPIO_Cfg.h LQlogo.h LQMT9V034.c LQMT9V034.h LQPIT.c LQPIT.h LQUART.c LQUART.h LQWDOG.c LQWDOG.h picture.h SCCB.c SCCB.h search.c search.h
  group utilities
    LQuser/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h print_scan.c print_scan.h
